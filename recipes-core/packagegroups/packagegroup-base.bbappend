RRECOMMENDS_packagegroup-base-usbgadget += "usbg"

RRECOMMENDS_packagegroup-base-wifi += "iw"
