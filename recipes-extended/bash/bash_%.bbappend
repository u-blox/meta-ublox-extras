# Set lower than the busybox priority of 50 in order to allow bash to be
# installed without becoming the default shell.
ALTERNATIVE_PRIORITY = "40"
